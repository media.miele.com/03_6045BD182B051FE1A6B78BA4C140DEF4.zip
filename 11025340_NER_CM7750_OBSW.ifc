Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 604f0424-1608-447a-92cb-b52cf79d7cc7, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T09:36:28+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11025340_NER_CM7750_OBSW:29775020_NER_11025340_CM7750_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, <Unnamed>, z_Miele_Design_Zinc_Steel, z_Miele_Design_OBSW, z_Miele_Design_Glass, z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 311 mm; Height: 420 mm; Depth: 445 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 29775020_NER_11025340_CM7750_OBSW; sets with these values: 2
